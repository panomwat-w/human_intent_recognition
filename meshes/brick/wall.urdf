Commit message: Add VR

File: meshes/brick/wall.urdf (robot description, URDF)
Before this commit: robot brick_clone, 1 links, 0 joints
Links:
- link box1: geometry collision box size=0.01 0.9 0.3; visual box size=0.01 0.9 0.3
