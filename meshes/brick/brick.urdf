Commit message: last update

File: meshes/brick/brick.urdf (robot description, URDF)
Before this commit: robot brick_clone, 1 links, 0 joints
Links:
- link box1: mass 0.2 -> 0.5
